options:
  parameters:
    author: Garavit....PerezJurado
    generate_options: qt_gui
    id: Practica1
    output_language: python
    title: Práctica 2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2, -1)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              # Inicialización de la clase base
              gr.sync_block.__init__(
                  self,
                  name='Promedios_de_tiempos',  # Nombre que aparecerá en GRC
                  in_sig=[np.float32],  # Entrada de tipo float32
                  out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]  # Salidas de tipo float32
              )
              self.acum_anterior = 0
              self.Ntotales = 0
              self.acum_anterior1 = 0
              self.acum_anterior2 = 0

          def work(self, input_items, output_items):
              x = input_items[0]  # Señal de entrada
              y0 = output_items[0]  # Promedio de la señal
              y1 = output_items[1]  # Media cuadrática de la señal
              y2 = output_items[2]  # RMS de la señal
              y3 = output_items[3]  # Potencia promedio de la señal
              y4 = output_items[4]  # Desviación estándar de la señal

              # Cálculo del promedio
              N = len(x)
              self.Ntotales += N
              acumulado = self.acum_anterior + np.cumsum(x)
              self.acum_anterior = acumulado[-1]  # Último valor acumulado
              y0[:] = acumulado / self.Ntotales  # Promedio acumulado

              # Cálculo de la media cuadrática
              x2 = np.multiply(x, x)#
              acumulado1 = self.acum_anterior1 + np.cumsum(x2)
              self.acum_anterior1 = acumulado1[-1]  # Último valor acumulado
              y1[:] = acumulado1 / self.Ntotales  # Media cuadrática acumulada

              # Cálculo del RMS
              y2[:] = np.sqrt(y1)  # RMS = raíz cuadrada de la media cuadrática

              # Cálculo de la potencia promedio
              y3[:] = np.multiply(y2, y2)  # Potencia promedio = RMS^2

              # Cálculo de la desviación estándar
              x3 = np.multiply(x - y0, x - y0)  # (x - promedio)^2
              acumulado2 = self.acum_anterior2 + np.cumsum(x3)
              self.acum_anterior2 = acumulado2[-1]  # Último valor acumulado
              y4[:] = np.sqrt(acumulado2 / self.Ntotales)  # Desviación estándar

              # Retornamos el número de elementos procesados por salida
              return len(x)
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviación Estandar"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia Promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media Cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_vector_source_x_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_2_1, '0']
- [epy_block_0, '1', qtgui_number_sink_0_2, '0']
- [epy_block_0, '1', qtgui_time_sink_x_2_1, '1']
- [epy_block_0, '2', qtgui_number_sink_0_3, '0']
- [epy_block_0, '2', qtgui_time_sink_x_2_1, '2']
- [epy_block_0, '3', qtgui_number_sink_0_1, '0']
- [epy_block_0, '3', qtgui_time_sink_x_2_1, '3']
- [epy_block_0, '4', qtgui_number_sink_0_0, '0']
- [epy_block_0, '4', qtgui_time_sink_x_2_1, '4']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
